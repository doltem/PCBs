# Repository doltem/PCBs

## EAGLE design Control.brd

Parts:
AGND: AGND; 1X01
C3, C4: 22pF; C025-024X044
I2C: I2C; 22-23-2041
IC2: 7805T; TO220H
IC3: LP2950Z; TO92
JP4: FTDI; 1X06
PDBUT1, PDBUT2, PDBUT3, PDBUT4: 10k; 0204/7
PSCL: 4k7; 0204/7
PSDA: 4k7; 0204/7
Q2: 16MHZ; HC49U-V
REF: 0,1uF; C050-024X044
REG3O, REG5O: 10uF; E5-5
REG5I: 1uF; E5-5
RELAY: RELAY; 22-23-2061
RES: 0,1uF; C050-024X044
RES1: 10k; 0204/7
RSSI1: PINHD-1X1; 1X01
RXASC: 10K; 0204/7
RXON: 10K; 0204/7
S1: TAC_SWITCHPTH; TACTILE-PTH
U$1: 2.1MMJACKTHM; PJ-102A
U$4: XBEE-1B1; XBEE-1
X1: BUT4; 22-23-2021
X2: BUT3; 22-23-2021
X3: AL1; 22-23-2031
X4: BUT2; 22-23-2021
X5: BUT1; 22-23-2021
X6: AL2; 22-23-2031
X7: AL3; 22-23-2031
X8: AL4; 22-23-2031
X9: DIG1; 22-23-2031
X10: DIG2; 22-23-2031
X11: DIG3; 22-23-2031
X12: DIG4; 22-23-2031
XASC: LED3MM
XDIV1: 10K; 0204/7
XDIV2: 15K; 0204/7
XON: LED3MM
ZU4: ATMEGA328P-PU; DIL28-3

Connections:
+3V3: IC3.3 (O), REG3O.+, U$4.1 (VDD)
+5V: I2C.4, IC2.3 (VO), IC3.1 (IN), JP4.4, PSCL.2, PSDA.2, REG5O.+, RES1.2, X1.2, X2.2, X3.3, X4.2, X5.2, X6.3, X7.3, X8.3, X9.3, X10.3, X11.3, X12.3, ZU4.7 (VCC), ZU4.20 (AVCC)
AGND: AGND.1, REF.2, X3.1, X6.1, X7.1, X8.1, ZU4.22 (AGND)
AL1: X3.2, ZU4.23 ((ADC0)PC0))
AL2: X6.2, ZU4.24 ((ADC1)PC1)
AL3: X7.2, ZU4.25 ((ADC2)PC2)
AL4: X8.2, ZU4.26 ((ADC3)PC3)
BUT1: PDBUT1.2, X5.1, ZU4.6 ((T0)PD4)
BUT2: PDBUT2.2, X4.1, ZU4.13 ((AIN1)PD7)
BUT3: PDBUT3.2, X2.1, ZU4.14 ((ICP)PB0)
BUT4: PDBUT4.2, X1.1, ZU4.15 ((OC1)PB1)
DIG1: X9.2, ZU4.4 ((INT0)PD2)
DIG2: X10.2, ZU4.5 ((INT1)PD3)
DIG3: X11.2, ZU4.11 ((T1)PD5)
DIG4: X12.2, ZU4.12 ((AIN0)PD6)
DTR: JP4.1, RES.1
GND: C3.1, C4.1, I2C.1, IC2.2 (GND), IC3.2 (GND), JP4.5, JP4.6, PDBUT1.1, PDBUT2.1, PDBUT3.1, PDBUT4.1, REG3O.-, REG5I.-, REG5O.-, RELAY.1, S1.1, S1.2, U$1.RING, U$4.10 (GND), X9.1, X10.1, X11.1, X12.1, XASC.K (C), XDIV2.1, XON.K (C), ZU4.8 (GND)
unnamed: RES.2, RES1.1, S1.3, S1.4, ZU4.1 (RESET)
unnamed: REF.1, ZU4.21 (AREF)
unnamed: C3.2, Q2.2, ZU4.10 (XTAL2)
unnamed: C4.2, Q2.1, ZU4.9 (XTAL1)
unnamed: U$4.3 (DIN), XDIV1.2, XDIV2.2
unnamed: RSSI1.1, U$4.6 (RSSI)
unnamed: RXON.2, XON.A
unnamed: RXON.1, U$4.13 (DIO9)
unnamed: RXASC.2, XASC.A
unnamed: RXASC.1, U$4.15 (DIO5)
REL1: RELAY.5, ZU4.16 ((SS)PB2)
REL2: RELAY.4, ZU4.17 ((MOSI)PB3)
REL3: RELAY.3, ZU4.18 ((MISO)PB4)
REL4: RELAY.2, ZU4.19 ((SCK)PB5)
RX: JP4.3, U$4.2 (DOUT), ZU4.2 ((RXD)PD0)
SCL: I2C.2, PSCL.1, ZU4.28 ((ADC5)PC5)
SDA: I2C.3, PSDA.1, ZU4.27 ((ADC4)PC4)
TX: JP4.2, XDIV1.1, ZU4.3 ((TXD)PD1)
VCC: IC2.1 (VI), REG5I.+, RELAY.6, U$1.TIP

Board: 2 copper layers, 85.1 x 59.4 mm, 44 parts (0 on the bottom side), 36 nets.

## EAGLE design Relay30.brd

Parts:
FLY1, FLY2, FLY3, FLY4: DIODEDO-1N4148; DO-1N4148
REL1, REL2, REL3, REL4: TERM; SCREWTERMINAL-5MM-2
RELAY1, RELAY2, RELAY3, RELAY4: HKE-CMP7; RELAY-T9A-2
RELIND1, RELIND2, RELIND3, RELIND4: LED3MM
RRELED1, RRELED2, RRELED3, RRELED4: 10K; 0204/7
RTPUL1, RTPUL2, RTPUL3, RTPUL4: 10k; 0204/7
RTREL1, RTREL2, RTREL3, RTREL4: 1K; 0204/7
TREL1, TREL2, TREL3, TREL4: 2N3904; TO92
X1: 22-23-2061

Connections:
GND: RTPUL1.1, RTPUL2.1, RTPUL3.1, RTPUL4.1, TREL1.3 (E), TREL2.3 (E), TREL3.3 (E), TREL4.3 (E), X1.1
M1-1: REL1.1, RELAY1.MAIN1
M1-2: REL1.2, RELAY1.NO
M2-1: REL2.1, RELAY2.MAIN1
M2-2: REL2.2, RELAY2.NO
M3-1: REL3.1, RELAY3.MAIN1
M3-2: REL3.2, RELAY3.NO
M4-1: REL4.1, RELAY4.MAIN1
M4-2: REL4.2, RELAY4.NO
unnamed: RTPUL1.2, RTREL1.2, TREL1.2 (B)
unnamed: FLY1.A, RELAY1.COIL2, RELIND1.K (C), TREL1.1 (C)
unnamed: RELIND1.A, RRELED1.2
unnamed: RTPUL2.2, RTREL2.2, TREL2.2 (B)
unnamed: FLY2.A, RELAY2.COIL2, RELIND2.K (C), TREL2.1 (C)
unnamed: RELIND2.A, RRELED2.2
unnamed: RTPUL3.2, RTREL3.2, TREL3.2 (B)
unnamed: FLY3.A, RELAY3.COIL2, RELIND3.K (C), TREL3.1 (C)
unnamed: RELIND3.A, RRELED3.2
unnamed: RTPUL4.2, RTREL4.2, TREL4.2 (B)
unnamed: FLY4.A, RELAY4.COIL2, RELIND4.K (C), TREL4.1 (C)
unnamed: RELIND4.A, RRELED4.2
REL1: RTREL1.1, X1.5
REL2: RTREL2.1, X1.4
REL3: RTREL3.1, X1.3
REL4: RTREL4.1, X1.2
VCC: FLY1.C, FLY2.C, FLY3.C, FLY4.C, RELAY1.COIL1, RELAY2.COIL1, RELAY3.COIL1, RELAY4.COIL1, RRELED1.1, RRELED2.1, RRELED3.1, RRELED4.1, X1.6

Board: 2 copper layers, 119.4 x 55.5 mm, 33 parts (0 on the bottom side), 26 nets.

## EAGLE design Temperature.brd

Parts:
DHT: DHT11; 22-23-2041
PULLUP: 10k; 0204/7
X1: CON; 22-23-2031

Connections:
+5V: DHT.4, PULLUP.1, X1.3
GND: DHT.1, X1.1
SIG: DHT.3, PULLUP.2, X1.2

Board: 2 copper layers, 21.6 x 26.3 mm, 3 parts (0 on the bottom side), 3 nets.

## EAGLE design PIR.brd

Board: 2 copper layers, 25.4 x 27.6 mm, 5 parts (0 on the bottom side), 5 nets.

Parts:
PIRPU1: 10K; 0204/7
RPT1: 4K7; 0204/7
T1: 2N3904; TO92
X1: SIGNAL; 22-23-2031
X2: PIR; 22-23-2031

Connections:
+5V: PIRPU1.1, X1.3, X2.3
GND: T1.3, X1.1, X2.1
unnamed: RPT1.1, X2.2
unnamed: RPT1.2, T1.2
SIG: PIRPU1.2, T1.1, X1.2

## EAGLE design IRLed.brd

Board: 2 copper layers, 20.3 x 28.9 mm, 3 parts (0 on the bottom side), 3 nets.

Parts:
IR: LED5MM
RIR: 220; 0204/7
X1: IR; 22-23-2031

Connections:
GND: IR.K, X1.1
unnamed: RIR.1, X1.2
unnamed: IR.A, RIR.2

## Commit log

2013-10-24 Commit Pertama
    24/10/13
    Fixed:
    -Main controller
    -Add relay schematic
    Unfixed:
    -Relay Power Source
2013-10-28 28/10/13
    Fixed:
    -Relay PCB
    -half Control PCB
    unfixed:
    -Control PCB GND separation
2013-10-28 28/10/13 - 2
    Fixed:
    -Relay & Control PCB
    Unfixed:
    -IR PCB
    -Temperature PCB
2013-10-28 Near Final
    Fixed:
    -Add IR and DHT11 pcb
    Unfixed:
    -PIR PCB
    -PIR Gate
    -Light Sensor PCB
2013-10-29 29/10/2013
    Minor improvement
2013-10-29 29/10/2013
    Fixed:
    -Naming in PIN
    -PIR & Light Sensor PCB
2013-11-11 11/10/3
    FIXED:
    -connector
    -refine route
2013-11-13 13/11/13
    Fixed:
    -Resistor Value

Notices in the files:
parts and their libraries:
SparkFun-Electromechanical: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
